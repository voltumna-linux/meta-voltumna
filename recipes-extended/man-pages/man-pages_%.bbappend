do_install:append() {
	rm ${D}/usr/share/man/man3/crypt_r.3
}
