EXTRA_OECONF:append:mingw32 = " --without-cng"
