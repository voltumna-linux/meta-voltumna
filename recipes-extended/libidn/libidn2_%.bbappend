FILES:${PN}-dev:append:mingw32 = " ${libdir}/*.def"
