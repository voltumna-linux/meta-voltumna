require arm-trusted-firmware.inc

ATF_VERSION = "v2.4.1"
ATF_BRANCH = "socfpga_${ATF_VERSION}"

SRCREV = "c841485a3730ba9193afc35b88b161ab0b30eaf7"
