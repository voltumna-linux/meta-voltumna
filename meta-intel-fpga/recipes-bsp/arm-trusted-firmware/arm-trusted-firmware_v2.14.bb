require arm-trusted-firmware.inc

LIC_FILES_CHKSUM = "file://docs/license.rst;md5=6ed7bace7b0bc63021c6eba7b524039e"

ATF_VERSION = "v2.14.0"
ATF_BRANCH = "socfpga_${ATF_VERSION}"

SRCREV = "4a4b4573e12fabd0a88e95952af49840db6b770d"
