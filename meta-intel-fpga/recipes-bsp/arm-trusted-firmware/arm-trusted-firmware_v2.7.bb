require arm-trusted-firmware.inc

LIC_FILES_CHKSUM = "file://docs/license.rst;md5=b2c740efedc159745b9b31f88ff03dde"

ATF_VERSION = "v2.7.0"
ATF_BRANCH = "socfpga_${ATF_VERSION}"

SRCREV = "7a4779938b57ed1eef2ee561af9fb027567c35c9"
