require arm-trusted-firmware.inc

LIC_FILES_CHKSUM = "file://docs/license.rst;md5=b5fbfdeb6855162dded31fadcd5d4dc5"

ATF_VERSION = "v2.11.1"
ATF_BRANCH = "socfpga_${ATF_VERSION}"

SRCREV = "fbf2b01a916c14e86ee1a95926fb99c6d0005dd7"
