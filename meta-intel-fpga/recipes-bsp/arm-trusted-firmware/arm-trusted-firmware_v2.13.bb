require arm-trusted-firmware.inc

LIC_FILES_CHKSUM = "file://docs/license.rst;md5=6ed7bace7b0bc63021c6eba7b524039e"

ATF_VERSION = "v2.13.1"
ATF_BRANCH = "socfpga_${ATF_VERSION}"

SRCREV = "376b6cd83a2ad2cc18189370fdeed2d658d2532d"
