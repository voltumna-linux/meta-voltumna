require arm-trusted-firmware.inc

LIC_FILES_CHKSUM = "file://docs/license.rst;md5=83b7626b8c7a37263c6a58af8d19bee1"

ATF_VERSION = "v2.12.1"
ATF_BRANCH = "socfpga_${ATF_VERSION}"

SRCREV = "b51695f4f8ee345738bf7c6e0a8edc1d4d637cdf"
