require u-boot-socfpga-common.inc

LIC_FILES_CHKSUM = "file://Licenses/README;md5=2ca5f2c35c8cc335f0a19756634782f1"

UBOOT_VERSION = "v2024.07"

SRCREV = "0dad0a0a4781fdcf8a3abcecdf563bff7f07606e"
