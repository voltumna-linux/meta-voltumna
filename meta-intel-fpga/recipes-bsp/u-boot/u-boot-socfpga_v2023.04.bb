require u-boot-socfpga-common.inc

LIC_FILES_CHKSUM = "file://Licenses/README;md5=2ca5f2c35c8cc335f0a19756634782f1"

UBOOT_VERSION = "v2023.04"

SRCREV = "d2d95a62e33767d29cd4fb1b7689042327addfc0"
