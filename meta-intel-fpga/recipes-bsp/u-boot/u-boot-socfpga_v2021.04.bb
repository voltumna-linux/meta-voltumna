require u-boot-socfpga-common.inc

LIC_FILES_CHKSUM = "file://Licenses/README;md5=5a7450c57ffe5ae63fd732446b988025"

UBOOT_VERSION = "v2021.04"

SRCREV = "bdc9a4409de9cef4408eebd81196fd63887ac78f"
