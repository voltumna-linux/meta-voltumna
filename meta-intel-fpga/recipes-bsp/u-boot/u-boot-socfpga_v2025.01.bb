require u-boot-socfpga-common.inc

LIC_FILES_CHKSUM = "file://Licenses/README;md5=2ca5f2c35c8cc335f0a19756634782f1"

UBOOT_VERSION = "v2025.01"

SRCREV = "cd3a9044d66128bc67c4ce60eb752ac528620f54"
