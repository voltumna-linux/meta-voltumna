require u-boot-socfpga-common.inc

LIC_FILES_CHKSUM = "file://Licenses/README;md5=2ca5f2c35c8cc335f0a19756634782f1"

UBOOT_VERSION = "v2025.10"

SRCREV = "a0db71cfad37d884e57fd49299b84df214bae9fd"
