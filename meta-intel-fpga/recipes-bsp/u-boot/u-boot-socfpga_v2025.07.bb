require u-boot-socfpga-common.inc

LIC_FILES_CHKSUM = "file://Licenses/README;md5=2ca5f2c35c8cc335f0a19756634782f1"

UBOOT_VERSION = "v2025.07"

SRCREV = "e5f40a8ed1ec65f20c4e2491bfe8e738efce6d94"
