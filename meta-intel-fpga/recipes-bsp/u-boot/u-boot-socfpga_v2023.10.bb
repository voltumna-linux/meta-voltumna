require u-boot-socfpga-common.inc

LIC_FILES_CHKSUM = "file://Licenses/README;md5=2ca5f2c35c8cc335f0a19756634782f1"

UBOOT_VERSION = "v2023.10"

SRCREV = "69d5338be07fba0c7c94579f38cc3c4014d1d355"
