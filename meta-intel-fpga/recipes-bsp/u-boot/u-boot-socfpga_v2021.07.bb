require u-boot-socfpga-common.inc

LIC_FILES_CHKSUM = "file://Licenses/README;md5=5a7450c57ffe5ae63fd732446b988025"

UBOOT_VERSION = "v2021.07"

SRCREV = "24e26ba4a0d8fe816e32e760537a3f356823ba7b"
