require u-boot-socfpga-common.inc

LIC_FILES_CHKSUM = "file://Licenses/README;md5=2ca5f2c35c8cc335f0a19756634782f1"

UBOOT_VERSION = "v2025.04"

SRCREV = "08197d3d7344b6d32f3ac6154771f2412a50d967"
