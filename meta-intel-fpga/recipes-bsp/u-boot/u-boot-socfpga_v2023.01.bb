require u-boot-socfpga-common.inc

LIC_FILES_CHKSUM = "file://Licenses/README;md5=2ca5f2c35c8cc335f0a19756634782f1"

UBOOT_VERSION = "v2023.01"

SRCREV = "0fa4e757b5b31173f3e063430d72ef2ff30412b2"
