LINUX_VERSION = "6.1"

SRCREV = "d345a46074e9b94be5a30a6d8f0df66b47cb59f1"

include linux-socfpga.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=6bc538ed5bd9a7fc9398086aedcd7e46"
