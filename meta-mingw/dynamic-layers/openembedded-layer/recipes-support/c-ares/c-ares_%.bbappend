EXTRA_OECMAKE:append:mingw32 = " -DCARES_SHARED=OFF -DCARES_STATIC=ON"
