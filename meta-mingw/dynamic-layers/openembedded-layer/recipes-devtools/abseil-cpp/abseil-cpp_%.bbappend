EXTRA_OECMAKE:remove:mingw32 = "-DBUILD_SHARED_LIBS=ON"
