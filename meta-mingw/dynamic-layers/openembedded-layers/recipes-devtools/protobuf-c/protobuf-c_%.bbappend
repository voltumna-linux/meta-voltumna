EXTRA_OECONF:append:mingw32 = " --disable-shared"
