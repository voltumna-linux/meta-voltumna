
FILES_${PN}-dev_append_mingw32 = " ${bindir}/gpg-error.exe"

