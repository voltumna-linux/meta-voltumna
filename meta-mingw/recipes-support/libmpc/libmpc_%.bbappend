EXTRA_OECONF:append:mingw32 = " --enable-static --disable-shared"
