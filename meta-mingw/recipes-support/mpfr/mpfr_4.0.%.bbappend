EXTRA_OECONF_append_mingw32 = " --disable-shared"