
FILES_libpcrecpp_mingw32 = "${bindir}/libpcrecpp*.dll"
FILES_libpcreposix_mingw32 = "${bindir}/libpcreposix*.dll"
FILES_pcregrep_mingw32 = "${bindir}/pcregrep.exe"
FILES_pcretest_mingw32 = "${bindir}/pcretest.exe"

