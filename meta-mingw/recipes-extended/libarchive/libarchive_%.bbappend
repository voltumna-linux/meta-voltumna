EXTRA_OECONF_append_mingw32 = " --without-cng"
