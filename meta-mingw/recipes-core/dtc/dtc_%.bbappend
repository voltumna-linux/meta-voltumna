RDEPENDS:${PN}-misc:remove:mingw32 = "bash"
