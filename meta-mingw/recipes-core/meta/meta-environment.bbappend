TCSCRIPTS ?= ""
TCSCRIPTS_sdkmingw32 = "toolchain-scripts-mingw32"

inherit ${TCSCRIPTS}
