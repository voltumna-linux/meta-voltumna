
FILES:${PN}-bin:mingw32 = "${bindir}/*.exe ${sbindir}/*.exe"

