RDEPENDS_${PN}_mingw32 = "\
    nativesdk-pkgconfig \
    nativesdk-libtool \
    nativesdk-qemu \
    nativesdk-make \
    "
