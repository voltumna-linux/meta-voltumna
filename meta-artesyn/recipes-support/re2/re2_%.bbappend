EXTRA_OECMAKE:append:ppce500v2 = "-DCMAKE_CXX_STANDARD_LIBRARIES=-latomic"
EXTRA_OECMAKE:append:ppc7400 = "-DCMAKE_CXX_STANDARD_LIBRARIES=-latomic"
