LINUX_VERSION = "6.12.43"
LINUX_VERSION_SUFFIX = "-lts"

LIC_FILES_CHKSUM = "file://COPYING;md5=6bc538ed5bd9a7fc9398086aedcd7e46"

SRCREV = "4ce49ba4bd8f598ff39e77b5d3d8c0bac1c9dcb1"

include linux-socfpga.inc
