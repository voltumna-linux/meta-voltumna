linux-ti-staging_%.bbappend