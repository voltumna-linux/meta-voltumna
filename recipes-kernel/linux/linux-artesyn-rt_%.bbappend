linux-artesyn_%.bbappend