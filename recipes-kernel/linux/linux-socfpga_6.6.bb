LINUX_VERSION = "6.6"

SRCREV = "8e56f4dd61552e0c33b6b36107457188c2cc0406"

include linux-socfpga.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=6bc538ed5bd9a7fc9398086aedcd7e46"
