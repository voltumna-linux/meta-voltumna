LINUX_VERSION = "5.12"

SRCREV = "4b159443997466eb36133c59e7aaef4e76f62f4a"

include linux-socfpga.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=6bc538ed5bd9a7fc9398086aedcd7e46"
