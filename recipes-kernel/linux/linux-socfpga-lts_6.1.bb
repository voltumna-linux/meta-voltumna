LINUX_VERSION = "6.1.55"
LINUX_VERSION_SUFFIX = "-lts"

LIC_FILES_CHKSUM = "file://COPYING;md5=6bc538ed5bd9a7fc9398086aedcd7e46"

SRCREV = "cb39d1e20633171b21ff9b474854ed61c1a730e9"

include linux-socfpga.inc
