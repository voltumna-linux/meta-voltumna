LINUX_VERSION = "5.13"

SRCREV = "d3040907268d4d1f71d1b918d4f6ac1b86ce4611"

include linux-socfpga.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=6bc538ed5bd9a7fc9398086aedcd7e46"
