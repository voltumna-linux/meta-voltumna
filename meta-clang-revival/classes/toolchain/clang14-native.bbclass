CLANGMAJORVERSION = "14"

require clang-native.inc
