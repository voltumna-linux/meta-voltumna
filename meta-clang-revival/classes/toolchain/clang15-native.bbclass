CLANGMAJORVERSION = "15"

require clang-native.inc
