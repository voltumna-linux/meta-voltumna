CLANGMAJORVERSION = "16"

require clang-native.inc
