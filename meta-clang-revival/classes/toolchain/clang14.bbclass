CLANGMAJORVERSION = "14"

require clang.inc
