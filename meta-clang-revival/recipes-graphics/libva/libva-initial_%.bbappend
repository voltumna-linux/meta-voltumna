PACKAGES = "${PN}"

FILES:${PN} += "${libdir} ${includedir}"
