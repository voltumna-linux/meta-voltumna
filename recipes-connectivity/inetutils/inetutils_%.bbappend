RDEPENDS:${PN}-rshd:remove = "xinetd"
RDEPENDS:${PN}-ftpd:remove = "xinetd"
RDEPENDS:${PN}-tftpd:remove = "xinetd"
RDEPENDS:${PN}-telnetd:remove = "xinetd"
RDEPENDS:${PN}:remove = "xinetd"
