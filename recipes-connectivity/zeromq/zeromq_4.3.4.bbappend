FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append = " \
	file://0001-Problem-Handshake-timeout-error-with-ZMTP_2_0.patch \
"

