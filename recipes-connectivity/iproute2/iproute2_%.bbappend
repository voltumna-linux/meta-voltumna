PACKAGECONFIG[bpf] = ",,libbpf,"
