CLANGMAJORVERSION = "15"

require clang.inc
