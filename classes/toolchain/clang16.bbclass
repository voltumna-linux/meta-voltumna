CLANGMAJORVERSION = "16"

require clang.inc
