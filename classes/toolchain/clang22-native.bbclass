CLANGMAJORVERSION = "22"

require clang-native.inc
