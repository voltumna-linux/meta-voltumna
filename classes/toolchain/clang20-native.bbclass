CLANGMAJORVERSION = "20"

require clang-native.inc
