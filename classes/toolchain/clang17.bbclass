CLANGMAJORVERSION = "17"

require clang.inc
