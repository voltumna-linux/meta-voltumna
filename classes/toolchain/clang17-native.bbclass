CLANGMAJORVERSION = "17"

require clang-native.inc
