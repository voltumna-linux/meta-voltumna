CLANGMAJORVERSION = "20"

require clang.inc
