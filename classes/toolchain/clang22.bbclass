CLANGMAJORVERSION = "22"

require clang.inc
