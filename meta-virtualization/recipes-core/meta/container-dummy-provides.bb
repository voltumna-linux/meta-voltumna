DUMMYARCH = "container-dummy-provides"
DUMMYPROVIDES = "\
   /bin/sh \
   /usr/bin/env \
"
DUMMYSDK_PKGDATA_VARNAME = "PKGDATA_DIR"
DUMMYSDK_EXTRASTAMP_VARNAME = "MACHINE"
require recipes-core/meta/dummy-sdk-package.inc
