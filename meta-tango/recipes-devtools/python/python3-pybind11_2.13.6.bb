SUMMARY = "Seamless operability between C++11 and Python"
HOMEPAGE = "https://github.com/pybind/pybind11"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=774f65abd8a7fe3124be2cdf766cd06f"

SRC_URI[sha256sum] = "ba6af10348c12b24e92fa086b39cfba0eff619b61ac77c406167d813b096d39a"

inherit pypi setuptools3
