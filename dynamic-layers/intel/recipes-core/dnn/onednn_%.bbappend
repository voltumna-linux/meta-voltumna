# onednn-dev will omit extra -dev packages in RRECOMMENDS this way
# added via PACKAGECONFIG[gpu]
RRECOMMENDS:onednn-dev[nodeprrecs] = "1"
