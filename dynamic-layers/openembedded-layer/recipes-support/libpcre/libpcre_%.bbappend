
FILES:libpcrecpp:mingw32 = "${bindir}/libpcrecpp*.dll"
FILES:libpcreposix:mingw32 = "${bindir}/libpcreposix*.dll"
FILES:pcregrep:mingw32 = "${bindir}/pcregrep.exe"
FILES:pcretest:mingw32 = "${bindir}/pcretest.exe"

