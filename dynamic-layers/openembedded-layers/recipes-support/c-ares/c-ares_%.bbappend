EXTRA_OECMAKE:append:mingw32 = "-DCARES_SHARED=OFF"
EXTRA_OECMAKE:append:mingw32 = "-DCARES_STATIC=ON"
