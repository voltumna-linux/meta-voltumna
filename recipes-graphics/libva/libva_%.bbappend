RPROVIDES:${PN}-dev = "${PN}-initial-dev"
