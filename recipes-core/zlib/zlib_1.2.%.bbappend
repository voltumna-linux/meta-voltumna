EXTRA_OEMAKE_append_mingw32 = " LDSHAREDLIBC=''"
