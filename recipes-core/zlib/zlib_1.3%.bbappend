EXTRA_OEMAKE:append:mingw32 = " LDSHAREDLIBC=''"
SOLIBS:mingw32 = ".so.*"
SOLIBSDEV:mingw32 = ".so"
