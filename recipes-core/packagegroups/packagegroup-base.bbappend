RDEPENDS:packagegroup-base-acpi = ""
