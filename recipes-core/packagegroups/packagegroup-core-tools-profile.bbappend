RDEPENDS:${PN}:remove = "\
    ${LTTNGTOOLS} \
    "

