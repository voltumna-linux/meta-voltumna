RDEPENDS_${PN}_remove = "gdbserver"

