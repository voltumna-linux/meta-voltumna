PACKAGECONFIG_remove_class-nativesdk_mingw32 = "python"
