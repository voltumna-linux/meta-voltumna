FILES:libmysqlclient-dev:append = " \
    ${libdir}/pkgconfig/libmariadb.pc"
