require linux-yocto-5.15.inc

PR := "${INC_PR}.0"

KBRANCH = "v5.15/standard/preempt-rt/base"
SRCREV_machine = "dba1b7d90813231782bdeda1bd169c93b35c94e0"
