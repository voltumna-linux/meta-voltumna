require grub-fixes.inc

RDEPENDS:${PN}:class-target:append = " efibootmgr"
