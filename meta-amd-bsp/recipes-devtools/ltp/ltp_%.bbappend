FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://0001-resolved-asm-compilation-issue.patch \
		"
