EXTRA_OECONF_append_mingw32 = "--enable-static --disable-shared"