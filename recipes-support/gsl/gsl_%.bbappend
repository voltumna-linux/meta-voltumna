BBCLASSEXTEND = "nativesdk"
MACHINE_FEATURES:append = " highly-optimized"
