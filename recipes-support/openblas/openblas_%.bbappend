MACHINE_FEATURES:remove = "qemu-usermode"
