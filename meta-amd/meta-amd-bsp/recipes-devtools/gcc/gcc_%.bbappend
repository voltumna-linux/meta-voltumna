FILES:${PN}:append:amd = "\
    ${bindir}/${TARGET_SYS}-${TARGET_PREFIX}gcc* \
    ${bindir}/${TARGET_SYS}-${TARGET_PREFIX}g++ \
"
