require linux-yocto-5.15.inc

PR := "${INC_PR}.0"

KBRANCH = "v5.15/standard/base"
SRCREV_machine = "0e51e571701842db33ad96f6ddc8cc6b23230627"
