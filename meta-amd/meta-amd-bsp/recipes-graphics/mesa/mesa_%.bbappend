#FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"
require ${BPN}.inc
