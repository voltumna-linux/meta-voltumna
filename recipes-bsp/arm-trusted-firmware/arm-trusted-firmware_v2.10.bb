require arm-trusted-firmware.inc

LIC_FILES_CHKSUM = "file://docs/license.rst;md5=b2c740efedc159745b9b31f88ff03dde"

ATF_VERSION = "v2.10.1"
ATF_BRANCH = "socfpga_${ATF_VERSION}"

SRCREV = "4837356693ede42b849ed72f1864cc9c76c53a46"
