require arm-trusted-firmware.inc

LIC_FILES_CHKSUM = "file://docs/license.rst;md5=b2c740efedc159745b9b31f88ff03dde"

ATF_VERSION = "v2.9.1"
ATF_BRANCH = "socfpga_${ATF_VERSION}"

SRCREV = "adf62fd4d254238539413c11b4af1be4c80f31f5"
