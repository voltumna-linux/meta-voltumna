require arm-trusted-firmware.inc

LIC_FILES_CHKSUM = "file://docs/license.rst;md5=713afe122abbe07f067f939ca3c480c5"

ATF_VERSION = "v2.5.1"
ATF_BRANCH = "socfpga_${ATF_VERSION}"

SRCREV = "f8cd53053ed7065f083ba89a99e5404a0b8b8194"
