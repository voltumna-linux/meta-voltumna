require arm-trusted-firmware.inc

ATF_VERSION = "v2.3"
ATF_BRANCH = "socfpga_${ATF_VERSION}"

SRCREV = "7009a0d7a0a0c7c8fa5834958dfdd8ee60cbf21d"
