require arm-trusted-firmware.inc

LIC_FILES_CHKSUM = "file://docs/license.rst;md5=b5fbfdeb6855162dded31fadcd5d4dc5"

ATF_VERSION = "v2.11.0"
ATF_BRANCH = "socfpga_${ATF_VERSION}"

SRCREV = "9aee18305b73651b74301483510c29fef9ce23ce"
