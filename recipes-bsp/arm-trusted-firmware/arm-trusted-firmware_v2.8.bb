require arm-trusted-firmware.inc

LIC_FILES_CHKSUM = "file://docs/license.rst;md5=b2c740efedc159745b9b31f88ff03dde"

ATF_VERSION = "v2.8.1"
ATF_BRANCH = "socfpga_${ATF_VERSION}"

SRCREV = "03a5d54432629af63bc203187825fbe7cdb8e37c"
