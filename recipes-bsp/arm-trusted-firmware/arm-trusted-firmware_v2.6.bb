require arm-trusted-firmware.inc

LIC_FILES_CHKSUM = "file://docs/license.rst;md5=b2c740efedc159745b9b31f88ff03dde"

ATF_VERSION = "v2.6.1"
ATF_BRANCH = "socfpga_${ATF_VERSION}"

SRCREV = "6fd554cdd10b9b68b1409b1b9aeb1af52f9edae6"
