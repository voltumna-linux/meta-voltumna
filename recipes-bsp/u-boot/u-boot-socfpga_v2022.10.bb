require u-boot-socfpga-common.inc

LIC_FILES_CHKSUM = "file://Licenses/README;md5=2ca5f2c35c8cc335f0a19756634782f1"

UBOOT_VERSION = "v2022.10"

SRCREV = "61ae22e548ebda525d5216d107e45f20eca70537"
