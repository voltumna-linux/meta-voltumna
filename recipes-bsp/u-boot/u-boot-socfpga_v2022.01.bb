require u-boot-socfpga-common.inc

LIC_FILES_CHKSUM = "file://Licenses/README;md5=5a7450c57ffe5ae63fd732446b988025"

UBOOT_VERSION = "v2022.01"

SRCREV = "bd5ba31770d191ba3cd64f3c431e205b1f8d89b3"
