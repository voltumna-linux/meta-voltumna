require u-boot-socfpga-common.inc

LIC_FILES_CHKSUM = "file://Licenses/README;md5=2ca5f2c35c8cc335f0a19756634782f1"

UBOOT_VERSION = "v2022.07"

SRCREV = "123cc7934a82d162d6d505339ca8efb11e170030"
