require u-boot-socfpga-common.inc

LIC_FILES_CHKSUM = "file://Licenses/README;md5=2ca5f2c35c8cc335f0a19756634782f1"

UBOOT_VERSION = "v2025.07"

SRCREV = "35abb4f1cedc94b17b8771b39b66ff4047fe35d1"
