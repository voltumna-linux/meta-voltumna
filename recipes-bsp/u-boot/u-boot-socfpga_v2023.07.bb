require u-boot-socfpga-common.inc

LIC_FILES_CHKSUM = "file://Licenses/README;md5=2ca5f2c35c8cc335f0a19756634782f1"

UBOOT_VERSION = "v2023.07"

SRCREV = "dab86d36f17b8c920acfd2349e657b00f0443c83"
