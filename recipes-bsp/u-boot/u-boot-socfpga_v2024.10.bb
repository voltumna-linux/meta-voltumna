require u-boot-socfpga-common.inc

LIC_FILES_CHKSUM = "file://Licenses/README;md5=2ca5f2c35c8cc335f0a19756634782f1"

UBOOT_VERSION = "v2024.10"

SRCREV = "29063bb1047f9f3dd85fd49e7745e0eef2200dfa"
