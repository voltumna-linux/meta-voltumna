require u-boot-socfpga-common.inc

LIC_FILES_CHKSUM = "file://Licenses/README;md5=2ca5f2c35c8cc335f0a19756634782f1"

UBOOT_VERSION = "v2024.04"

SRCREV = "135e53726d3dfbe55b4d61c2bf3fdf32cdc372e5"
