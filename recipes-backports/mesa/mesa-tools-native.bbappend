require mesa-version-override.inc

DEPENDS:remove = "libclc-native"
DEPENDS:prepend = "mesa-libclc-native "
