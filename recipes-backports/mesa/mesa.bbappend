require mesa-version-override.inc

DEPENDS += "venus-protocol"
