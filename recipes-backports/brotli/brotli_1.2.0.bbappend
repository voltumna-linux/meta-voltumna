SRC_URI:remove = "git://github.com/google/brotli.git;branch=master;protocol=https"

PV = "1.2.1"
SRC_URI:prepend = "git://github.com/google/brotli.git;branch=v1.2;protocol=https"
SRCREV = "db24a98aed38a16de78cc05ca15cdd8dc2a0d92d"
