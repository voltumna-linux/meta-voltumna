COMPATIBLE_HOST:ppce500v2 = "(.*)-linux-gnuspe"
COMPATIBLE_HOST:ppc7400 = "(.*)-linux"

