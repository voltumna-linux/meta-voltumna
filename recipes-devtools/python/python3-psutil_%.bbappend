BBCLASSEXTEND = "native nativesdk"

RDEPENDS:${PN}-tests:class-nativesdk = ""
