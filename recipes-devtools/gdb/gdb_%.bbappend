do_install:append() {
	rm ${D}${datadir}/info/ctf-spec.info
}
