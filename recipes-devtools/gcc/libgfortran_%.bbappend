DEPENDS:append = " virtual/${TARGET_PREFIX}gcc"
