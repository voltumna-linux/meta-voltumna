do_install_append() {
	rm -f ${D}/usr/share/bin/arm-none-eabi-gdb-py
}
